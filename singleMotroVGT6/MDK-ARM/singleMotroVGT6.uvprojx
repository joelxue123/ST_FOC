# Keil uVision project singleMotroVGT6.uvprojx, settings and files
target singleMotroVGT6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: singleMotroVGT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Core\Inc;    ..\Drivers\STM32F4xx_HAL_Driver\Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    ..\MCSDK_v5.4.4-Full\MotorControl\MCSDK\MCLib\Any\Inc;    ..\MCSDK_v5.4.4-Full\MotorControl\MCSDK\UILibrary\Inc;    ..\MCSDK_v5.4.4-Full\MotorControl\MCSDK\SystemDriveParams;    ..\MCSDK_v5.4.4-Full\MotorControl\MCSDK\MCLib\F4xx\Inc;    ..\Drivers\CMSIS\DSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: mc_api.c mc_config.c mc_math.c mc_interface.c mc_parameters.c mc_tasks.c motor_control_protocol.c motorcontrol.c regular_conversion_manager.c stm32f4xx_mc_it.c ui_task.c user_interface.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Src/: circle_limitation.c bus_voltage_sensor.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c fast_div.c feed_forward_ctrl.c flux_weakening_ctrl.c hall_speed_pos_fdbk.c inrush_current_limiter.c max_torque_per_ampere.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c sto_cordic_speed_pos_fdbk.c sto_pll_speed_pos_fdbk.c trajectory_ctrl.c virtual_bus_voltage_sensor.c virtual_speed_sensor.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Src/: frame_communication_protocol.c ui_irq_handler.c unidirectional_fast_com.c usart_frame_communication_protocol.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: r3_2_f4xx_pwm_curr_fdbk.c
software components: CMSIS:CORE 4.3.0
